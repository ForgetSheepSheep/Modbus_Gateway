# Keil uVision project termplate.uvprojx, settings and files
target App_1.0.0 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08004000,0x07C000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: termplate
  AfterMake: fromelf --bin --output=.\Objects\@L.bin .\Objects\@L.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\app;..\bsp;..\driver;..\library\Include;..\startup;..\user;..\libs;..\component;..\Middleware\FreeModbus
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x7c000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c
  group app
    ../app/: app_task.c app_4g.c app_modbus_master.c
  group component
    ../component/component_4g/: component_4g.c
    ../component/component_ota/: component_ota.c
    ../component/component_crc32/: component_crc32.c
    ../component/component_flash_fw/: component_flash_fw.c
  group driver
    ../driver/driver_uart/: driver_uart.c
    ../driver/driver_4g_uart/: driver_4g_uart.c
    ../driver/driver_led/: driver_led.c
    ../driver/driver_key/: driver_key.c
    ../driver/driver_spi/: driver_spi.c
    ../driver/driver_gd25q128/: driver_gd25q128.c
    ../driver/driver_flash/: driver_flash.c
    ../driver/driver_eeprom/: driver_eeprom.c
    ../driver/driver_delay/: driver_delay.c
  group bsp
    ../bsp/bsp_tick/: bsp_tick.c
  group library
    ../library/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group startup
    ../startup/: startup_gd32f30x_hd.s system_gd32f30x.c
  group libs
    ../libs/ring_buffer/: ring_buffer.c
    ../libs/cJSON/: cJSON.c
  group FreeModbus
    ../Middleware/FreeModbus/: modbus_rtu.c modbus_crc.c port_serial.c port_timer.c
