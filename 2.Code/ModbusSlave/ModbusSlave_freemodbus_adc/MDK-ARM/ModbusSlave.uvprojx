# Keil uVision project ModbusSlave.uvprojx, settings and files
target ModbusSlave (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F030CCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803F7FF) CLOCK(8000000) CPUTYPE("Cortex-M0") TZ
  output: ModbusSlave +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030xC
  c include: ../Core/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;../ModuleDriver;../Application;../Libs;../Middleware/FreeModbus/modbus/include;../Middleware/FreeModbus/port;../Middleware/FreeModbus;../Middleware/FreeModbus/modbus/rtu
  memory RVCT4: ROM 0x8000000 size 0x3f800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f030xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_tim.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group ModuleDriver
    ../ModuleDriver/driver_io/: driver_io.c
    ../ModuleDriver/driver_systick/: driver_systick.c
    ../ModuleDriver/driver_adc/: driver_adc.c
    ../ModuleDriver/driver_iic/: driver_iic.c
    ../ModuleDriver/driver_key/: driver_key.c
    ../ModuleDriver/driver_ah20/: driver_ah20.c
  group Application
    ../Application/: app_task.c app_modbusslave.c app_param.c
  group Libs
    ../Libs/ring_buffer/: ring_buffer.c
  group Middleware/modbus
    ../Middleware/FreeModbus/modbus/functions/: mbfuncholding.c mbutils.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncinput.c mbfuncother.c
    ../Middleware/FreeModbus/modbus/: mb.c
    ../Middleware/FreeModbus/: modbus_slave.c
    ../Middleware/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
  group Middleware/port
    ../Middleware/FreeModbus/port/: portevent.c portserial.c porttimer.c
software components: CMSIS:CORE 4.3.0
